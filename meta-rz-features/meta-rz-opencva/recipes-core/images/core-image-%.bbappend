require include/drpai/drpai_base.inc
